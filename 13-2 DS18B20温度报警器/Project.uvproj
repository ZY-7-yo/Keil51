# Keil uVision project Project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51RC2 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x7FFF)  XRAM (0-0x3FF) CLOCK(40000000) MODP2
  output: Project +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c Delay.c Delay.h LCD1602.c LCD1602.h AT24C02.c AT24C02.h I2C.c I2C.h OneWire.h DS18B20.c DS18B20.h OneWire.c Key.c Key.h Timer0.h
    ../12-2 秒表（定时器扫描按键数码管）/: Timer0.c
