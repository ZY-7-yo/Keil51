# Keil uVision project Project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51RC2 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x7FFF)  XRAM (0-0x3FF) CLOCK(40000000) MODP2
  output: Project +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c Delay.c Delay.h Nixie.c Nixie.h Key.c Key.h Timer0.c Timer0.h AT24C02.c AT24C02.h I2C.c I2C.h
