# Keil uVision project Project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51RC2 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x7FFF)  XRAM (0-0x3FF) CLOCK(40000000) MODP2
  output: Project +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c Key.c Key.h Delay.c Delay.h Nixie.c Nixie.h Timer1.c Timer1.h Motor.c Motor.h Timer0.c Timer0.h Int0.c Int0.h IR.c IR.h
